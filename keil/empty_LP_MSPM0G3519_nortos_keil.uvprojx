# Keil uVision project empty_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3519_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3519_nortos_keil +hex
  BeforeMake: cmd.exe /C "$Psyscfg_local.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__,ARM_MATH_CM0PLUS
  c include: ..;../Drive;../apply;../Algorithm;../Task;C:/ti/mspm0_sdk_2_10_00_04/source/third_party/CMSIS/Core/Include;C:/ti/mspm0_sdk_2_10_00_04/source/third_party/CMSIS/DSP/Include;C:/ti/mspm0_sdk_2_10_00_04/source/third_party/CMSIS/DSP/PrivateInclude;C:/ti/mspm0_sdk_2_10_00_04/source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: ROM 0x20200000 size 0x20000
  memory RVCT7: ROM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: ./mspm0g3519.sct
  link misc: C:/ti/mspm0_sdk_2_10_00_04/source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a C:/ti/mspm0_sdk_2_10_00_04/source/third_party/CMSIS/DSP/lib/keil/m0p/arm_cortexM0l_math.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
    ../Drive/: headfile.h databyte.h datatype.h
  group Drive
    ../Drive/: LED.c LED.h Beep.c Beep.h motor.c motor.h uart.c uart.h Delay.c Delay.h pid.c pid.h spi.c spi.h LCD_ST7735.c LCD_ST7735.h lcdfont.h EncoderExti.c EncoderExti.h Key.c Key.h
  group Algorithm
    ../Algorithm/: mahony_filter.c mahony_filter.h imu_attitude.c imu_attitude.h kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h
  group Task
    ../Task/: task.c task.h
  group apply
    ../apply/: ICM42688.c ICM42688.h MotorControl.c MotorControl.h Encoder.c Encoder.h GraySensor.c GraySensor.h Time.c Time.h vofa.c vofa.h
